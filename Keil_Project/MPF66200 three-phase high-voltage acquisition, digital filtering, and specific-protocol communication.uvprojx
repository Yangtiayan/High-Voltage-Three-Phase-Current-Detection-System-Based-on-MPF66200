# Keil uVision project MPF66200 three-phase high-voltage acquisition, digital filtering, and specific-protocol communication.uvprojx, settings and files
target MPF662xx (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: TriggerTIMR +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  AfterMake: fromelf --text -a -c -o "$L@L.asm" "#L"
  c flags: Optim=2 v6Lang=1 v6LangP=3
  c define: CHIP_MPF662xx
  c include: ..\..\..\..\..\..\MPF662xx_Firmware_Library\CMSIS\Include;..\..\..\..\..\..\MPF662xx_Firmware_Library\Device\MPS\MPF662xx\Include;..\..\..\..\..\..\MPF662xx_Firmware_Library\MPF662xx_Standard_Peripheral\Include
  asm define: CHIP_MPF662xx
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application
    ../User/: main.c
  group CMSIS
    ../../../../../../MPF662xx_Firmware_Library/Device/MPS/MPF662xx/Source/: system_mpf662xx.c
  group Startup
    ../../../../../../MPF662xx_Firmware_Library/Device/MPS/MPF662xx/Source/ARM/: startup_mpf662xx.s
  group Peripherals
    ../../../../../../MPF662xx_Firmware_Library/MPF662xx_Standard_Peripheral/Source/: mpf662xx_adc.c mpf662xx_exti.c mpf662xx_flash.c mpf662xx_gpio.c mpf662xx_i2c.c mpf662xx_port.c mpf662xx_pwm.c mpf662xx_timr.c mpf662xx_uart.c mpf662xx_wdt.c mpf662xx_dma.c mpf662xx_div.c
